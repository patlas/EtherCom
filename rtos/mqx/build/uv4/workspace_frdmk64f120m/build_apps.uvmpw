<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\examples\demo\build\uv4\demo_frdmk64f120m\demo_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event\build\uv4\event_frdmk64f120m\event_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello\build\uv4\hello_frdmk64f120m\hello_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr\build\uv4\isr_frdmk64f120m\isr_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog\build\uv4\klog_frdmk64f120m\klog_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log\build\uv4\log_frdmk64f120m\log_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo\build\uv4\lwdemo_frdmk64f120m\lwdemo_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent\build\uv4\lwevent_frdmk64f120m\lwevent_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog\build\uv4\lwlog_frdmk64f120m\lwlog_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq\build\uv4\lwmsgq_frdmk64f120m\lwmsgq_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem\build\uv4\lwsem_frdmk64f120m\lwsem_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg\build\uv4\msg_frdmk64f120m\msg_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex\build\uv4\mutex_frdmk64f120m\mutex_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill\build\uv4\nill_frdmk64f120m\nill_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem\build\uv4\sem_frdmk64f120m\sem_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskat\build\uv4\taskat_frdmk64f120m\taskat_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq\build\uv4\taskq_frdmk64f120m\taskq_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\test\build\uv4\test_frdmk64f120m\test_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\timer\build\uv4\timer_frdmk64f120m\timer_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\watchdog\build\uv4\watchdog_frdmk64f120m\watchdog_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
