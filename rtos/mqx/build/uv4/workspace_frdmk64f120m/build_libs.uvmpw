<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\build\uv4\bsp_frdmk64f120m\bsp_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\build\uv4\psp_frdmk64f120m\psp_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\nshell\build\uv4\nshell_frdmk64f120m\nshell_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx_stdlib\build\uv4\mqx_stdlib_frdmk64f120m\mqx_stdlib_frdmk64f120m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
